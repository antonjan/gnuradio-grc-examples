options:
  parameters:
    author: F1ATB - BUHART
    description: 'TX SSB '
    generate_options: no_gui
    id: remote_tx_ssb_v1
    output_language: python
    run_options: run
    title: SSB Transmitter V1 - F1ATB - MAY 2020
  states: {}

blocks:
- name: Fr_TX
  id: variable
  parameters:
    value: '145100000'
  states: {}
- name: GainBB_TX
  id: variable
  parameters:
    value: '40'
  states: {}
- name: GainIF_TX
  id: variable
  parameters:
    value: '300'
  states: {}
- name: GainRF_TX
  id: variable
  parameters:
    value: '100'
  states: {}
- name: LSB_USB
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LSB_USB*1500
    low_cutoff_freq: '-1300+LSB_USB*1500'
    samp_rate: samp_rate/240
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LSB_USB
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    maxoutbuf: '2048'
    port: '9005'
    psize: '512'
    type: short
    vlen: '1'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '64'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '0x00664765'
    bb_gain0: GainBB_TX
    freq0: Fr_TX
    gain0: GainRF_TX
    if_gain0: GainIF_TX
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '240'
    taps: ''
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9004'
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_0, '0', hilbert_fc_0, '0']
- [blocks_udp_source_0, '0', blocks_short_to_float_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_null_sink_0, '0']
- [rational_resampler_xxx_1, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
