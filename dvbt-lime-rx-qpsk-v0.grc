options:
  parameters:
    author: hb9dug
    description: DVB-T gnuradio example modified for Lime Mini SDR
    generate_options: qt_gui
    id: dvbt_lime_rx
    output_language: python
    title: Experimental DVB-T Receiver for Lime Mini
  states: {}

blocks:
- name: decim_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: RX DVB-T bandwidth
    label0: 1 MHZ
    label1: 500 KHz
    label2: 250 KHz
    label3: 125 KHz
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,3,1,1
    label: RX Frequency [Hz]
    type: int
    value: freq_central+freq_fine
  states: {}
- name: freq_central
  id: variable
  parameters:
    value: '437000000'
  states: {}
- name: freq_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: Frequency Fine Adjust [Hz]
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: '-10000'
    step: '10'
    stop: '10000'
    value: '0'
  states: {}
- name: nco_adjust
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,4,1,1
    label: NCO Correction [Hz]
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,3,1,2
    label: RF Gain [dB]
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '73'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int((4000000*8)/7)
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: bandwidth_decim_factor
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\ndef factor(arg):\n\n\tif arg==1:\n        \treturn 4\n\telif arg==2:\n\t\treturn 8\n\telif arg==3:\n\t\treturn 16\n\telse:\n\t\treturn 2\n\t\n\t\t\n"
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: decim_select
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: decim_select
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    comment: |-
      The Transport Stream (TS) can be displayed by :
      VLC  -->   tcp://@127.0.0.1:10000
      SMPLAYER  -->  tcp://127.0.0.1:10000
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '10000'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1512'
    type: byte
  states: {}
- name: dtv_dvbt_bit_inner_deinterleaver_0
  id: dtv_dvbt_bit_inner_deinterleaver
  parameters:
    constellation: qpsk
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_convolutional_deinterleaver_0
  id: dtv_dvbt_convolutional_deinterleaver
  parameters:
    I: '12'
    M: '17'
    blocks: '136'
  states: {}
- name: dtv_dvbt_demap_0
  id: dtv_dvbt_demap
  parameters:
    constellation: qpsk
    gain: '1'
    hierarchy: nh
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_demod_reference_signals_0
  id: dtv_dvbt_demod_reference_signals
  parameters:
    cell_id: '0'
    code_rate_hp: C2_3
    code_rate_lp: C2_3
    constellation: qpsk
    guard_interval: GI_1_32
    hierarchy: nh
    include_cell_id: call_id_yes
    transmission_mode: T2k
    type: complex
  states: {}
- name: dtv_dvbt_energy_descramble_0
  id: dtv_dvbt_energy_descramble
  parameters:
    nsize: '8'
  states: {}
- name: dtv_dvbt_ofdm_sym_acquisition_0
  id: dtv_dvbt_ofdm_sym_acquisition
  parameters:
    cp_length: '64'
    fft_length: fft_len
    occupied_tones: '1705'
    snr: '10'
    type: complex
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {}
- name: dtv_dvbt_symbol_inner_interleaver_0
  id: dtv_dvbt_symbol_inner_interleaver
  parameters:
    direction: Deinterleave
    transmission_mode: T2k
  states: {}
- name: dtv_dvbt_viterbi_decoder_0
  id: dtv_dvbt_viterbi_decoder
  parameters:
    block_size: '768'
    code_rate: C2_3
    constellation: qpsk
    hierarchy: nh
    type: b
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    digital_bandw_ch0: (samp_rate/8)*3
    gain_dB_ch0: rf_gain
    gain_dB_ch1: rf_gain
    lna_path_ch0: '3'
    lna_path_ch1: '3'
    nco_freq_ch0: nco_adjust
    nco_freq_ch1: nco_adjust
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    comment: |-
      for Mode 2k, Constellation QPSK,  FEC 2/3 and Guard 1/32
      others FEC are possible by changing the value in the following blocks:
      -  Demod Reference Signals
       - ViterbiDecoder
    note: Configuration
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"miri=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,3,1,2
    name: Constellation
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/bandwidth_decim_factor.factor(decim_select)
    comment: |-
      Auto-scale can be switch OFF on TAB General
      Control Panel can be switch ON on TAB Config
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,3
    name: RX Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: OFDM-1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: OFDM-2
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: OFDM-3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: OFDM-1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: OFDM-2
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: OFDM-3
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_2, '0']
- [blocks_selector_0, '2', rational_resampler_xxx_1, '0']
- [blocks_selector_0, '3', rational_resampler_xxx_3, '0']
- [blocks_selector_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_1, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_1, '0', dtv_dvbt_viterbi_decoder_0, '0']
- [dtv_dvbt_bit_inner_deinterleaver_0, '0', blocks_vector_to_stream_1, '0']
- [dtv_dvbt_convolutional_deinterleaver_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [dtv_dvbt_demap_0, '0', dtv_dvbt_symbol_inner_interleaver_0, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', blocks_vector_to_stream_0, '0']
- [dtv_dvbt_demod_reference_signals_0, '0', virtual_sink_1, '0']
- [dtv_dvbt_energy_descramble_0, '0', blocks_tcp_server_sink_0, '0']
- [dtv_dvbt_ofdm_sym_acquisition_0, '0', fft_vxx_0, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', dtv_dvbt_energy_descramble_0, '0']
- [dtv_dvbt_symbol_inner_interleaver_0, '0', dtv_dvbt_bit_inner_deinterleaver_0, '0']
- [dtv_dvbt_viterbi_decoder_0, '0', virtual_sink_1_0, '0']
- [fft_vxx_0, '0', dtv_dvbt_demod_reference_signals_0, '0']
- [limesdr_source_0, '0', analog_agc2_xx_0, '0']
- [osmosdr_source_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '2']
- [rational_resampler_xxx_2, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_3, '0', blocks_selector_1, '3']
- [virtual_source_0, '0', dtv_dvbt_ofdm_sym_acquisition_0, '0']
- [virtual_source_1, '0', dtv_dvbt_demap_0, '0']
- [virtual_source_1_0, '0', dtv_dvbt_convolutional_deinterleaver_0, '0']

metadata:
  file_format: 1
