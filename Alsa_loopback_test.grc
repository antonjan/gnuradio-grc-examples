options:
  parameters:
    author: Anton Janovsky ZR6AIC
    generate_options: qt_gui
    id: test_alsa_loopback
    output_language: python
    title: Testing Alsa loopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:1,0,1
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:1,1,1
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
