options:
  parameters:
    author: Anton Janovsky (ZR6AIC)
    generate_options: qt_gui
    id: Signal_gen_70cm
    output_language: python
    title: 'Signal_gen_70cm '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: Select_audio_input
    label0: 1 Khz
    label1: Speaker Audio
    label2: Play AFSK message Mode 0
    label3: Play AFSK Message Mod 1
    label4: Play AFSK Message Mode 2
    num_opts: '5'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: '430000000'
    step: '100'
    stop: '440000000'
    value: '435080200'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: Aplitude audio
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Aplitude rf
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: variable_qtgui_range_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Aplitude rf  IF
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_qtgui_range_0_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: Aplitude rf  BB
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    label: Deviastion
    orient: Qt.Horizontal
    start: '1000'
    step: '10'
    stop: '25000'
    value: '5000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate_audio
    fh: '-1'
    max_dev: variable_qtgui_range_1
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_audio
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate_audio
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0_0
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_0
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '44100'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anton/africube_controle/aprs_test.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0_0
  id: blocks_wavfile_source
  parameters:
    repeat: 'True'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: variable_qtgui_range_0_0_0_0_0
    freq0: variable_qtgui_range_0
    gain0: variable_qtgui_range_0_0_0
    if_gain0: variable_qtgui_range_0_0_0_0
    sample_rate: '2400000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '50'
    taps: '1'
    type: ccc
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0, '0']
- [audio_source_0, '0', blocks_selector_0, '1']
- [audio_source_0, '0', blocks_selector_0, '3']
- [audio_source_0, '0', blocks_selector_0, '4']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_selector_0, '2']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_selector_0, '3']
- [blocks_wavfile_source_0_0_0, '0', blocks_selector_0, '4']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
