options:
  parameters:
    category: Custom
    description: Transmits NBFM from pc audio
    generate_options: qt_gui
    id: NBFM_XCVR
    output_language: python
    title: NBFM Transceiver
  states: {}

blocks:
- name: spike_freq
  id: variable
  parameters:
    value: 144e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Audio Autput level
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: 144e6
    step: '0.1'
    stop: 146e6
    value: 145.300e6
  states: {}
- name: variable_qtgui_range_2
  id: variable_qtgui_range
  parameters:
    label: Squelch
    orient: Qt.Horizontal
    start: '-160'
    step: '0.1'
    stop: '10'
    value: '-50'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5.0e3
    quad_rate: '48000'
    tau: '.75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '9e-2'
    gate: 'True'
    ramp: '0'
    threshold: variable_qtgui_range_2
    type: complex
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '40'
    corr0: '50'
    dc_offset_mode0: '2'
    freq0: variable_qtgui_range_1
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '40'
    iq_balance_mode0: '2'
    sample_rate: 1.2e6
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 1.2e6
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 1.2e6
    fc: '0'
    fftsize: '1024'
    int_min: '-100'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1200000'
    interp: '48000'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_0, '0', analog_pwr_squelch_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
