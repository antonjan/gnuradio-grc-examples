<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_demod</value></param>
<param><key>author</key><value>Johannes Mittendorfer</value></param>
<param><key>description</key><value>Demodulates a FSK signal</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FSK demod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>(high-low)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>center+deviation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low</value></param>
<param><key>value</key><value>center-deviation</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>comment</key><value>Normalize the signal for clock recovery</value></param>
<param><key>gain</key><value>0.6</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>1e-4</value></param>
<param><key>reference</key><value>0.6</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>comment</key><value>Convert the frequency shift to a number

HLHHLLL -&gt; 1011000</value></param>
<param><key>gain</key><value>samp_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>comment</key><value>Flip 1 and 0.</value></param>
<param><key>const</key><value>mult</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center</value></param>
<param><key>label</key><value>Center frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>160e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>deviation</value></param>
<param><key>label</key><value>Frequency deviation</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>400</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_2_0</value></param>
<param><key>comment</key><value>Make signal digital</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_1</value></param>
<param><key>comment</key><value>Recover the signal clock</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>gain_omega</key><value>0.25*0.175*0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0</value></param>
<param><key>omega</key><value>1/((1./samp_rate)*(high-low)*2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>low+(high-low)/2</value></param>
<param><key>comment</key><value>Filter out the signal between high and low</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, samp_rate, (high-low), 200)</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mult</value></param>
<param><key>comment</key><value>Multiplication of raw float values (e.g. -1 when higher frequency is 0 and lower is 1)</value></param>
<param><key>label</key><value>Multiplication</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>demoded</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_2_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
