options:
  parameters:
    author: John Ackermann N8UR
    category: Custom
    generate_options: qt_gui
    id: demo6
    output_language: python
    title: GRC Tutorial
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Freq (MHz)
    min_len: '10'
    rangeType: int
    start: '1'
    step: '1'
    stop: '2000'
    value: '144'
    widget: counter
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: int(samp_rate/decimation)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '72'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,7,1,1
    label: Mode
    label0: FM
    label1: AM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain
    min_len: '10'
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Squelch
    min_len: '10'
    start: '-100'
    step: '1'
    stop: '0'
    value: '-55'
    widget: counter
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Tune Freq (kHz)
    min_len: '10'
    rangeType: int
    start: '-600'
    step: '5'
    stop: '600'
    value: '390'
    widget: counter
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: Volume
    min_len: '10'
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
    widget: counter
  states: {}
- name: xlate_lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_width/2
    gain: '1.0'
    samp_rate: samp_rate
    width: channel_width/10
    win: firdes.WIN_HAMMING
  states: {}
- name: afsk_aprs2inet_0
  id: afsk_aprs2inet
  parameters:
    debug_level: '4'
    sample_rate: channel_width
  states: {}
- name: afsk_ax25decode_0
  id: afsk_ax25decode
  parameters:
    debug_level: '4'
    sample_rate: channel_width
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: channel_width
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: channel_width
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: channel_width
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2450'
    low_cutoff_freq: '950'
    samp_rate: channel_width
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {}
- name: blks2_tcp_sink_0
  id: blks2_tcp_sink
  parameters:
    addr: 127.0.0.1
    port: '14580'
    server: 'True'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/50.0
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: detectMarkSpace_0
  id: detectMarkSpace
  parameters:
    Frequency: '1200'
    attack: '0.1'
    decay: '0.001'
    samp_rate: channel_width
  states: {}
- name: detectMarkSpace_1
  id: detectMarkSpace
  parameters:
    Frequency: '2200'
    attack: '0.1'
    decay: '0.001'
    samp_rate: channel_width
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq * 1e3
    decim: decimation
    samp_rate: samp_rate
    taps: xlate_lpf_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,2,8
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: channel_width
    fc: (center_freq *1e6) + (tune_freq *1e3)
    fftsize: '1024'
    gui_hint: 4,0,5,4
    name: '"Channel Spectrum"'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: center_freq * 1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: show_text_0
  id: show_text
  parameters:
    gui_hint: 4,4,5,4
  states: {}

connections:
- [afsk_aprs2inet_0, '0', blks2_tcp_sink_0, '0']
- [afsk_ax25decode_0, '0', show_text_0, '0']
- [analog_agc2_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blks2_selector_0, '0']
- [analog_fm_demod_cf_0, '0', blks2_selector_0, '1']
- [analog_pwr_squelch_xx_0, '0', analog_agc2_xx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', detectMarkSpace_0, '0']
- [band_pass_filter_0, '0', detectMarkSpace_1, '0']
- [blks2_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_sub_xx_0, '0', afsk_aprs2inet_0, '0']
- [blocks_sub_xx_0, '0', afsk_ax25decode_0, '0']
- [detectMarkSpace_0, '0', blocks_sub_xx_0, '0']
- [detectMarkSpace_1, '0', blocks_sub_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
