options:
  parameters:
    author: anton
    generate_options: qt_gui
    id: FM_audio_player
    output_language: python
    title: This is a fm audio Player
  states: {}

blocks:
- name: File_name
  id: variable
  parameters:
    value: '"audio1.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '4800000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate_0
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: File_name
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate_0
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Audio Signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', osmosdr_sink_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
