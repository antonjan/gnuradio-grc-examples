options:
  parameters:
    author: Anton Janovsky ZR6AIC
    generate_options: qt_gui
    id: SSB_transmitter
    output_language: python
    title: SSB Transmitter
  states: {}

blocks:
- name: samp_rate_Audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_Baseband
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: samp_rate_Baseband_Hackrf
  id: variable
  parameters:
    value: '2112000'
  states: {}
- name: variable_qtgui_chooser_PTT
  id: variable_qtgui_chooser
  parameters:
    label: PTT
    label0: TX
    label1: RX
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_chooser_PTT_0
  id: variable_qtgui_chooser
  parameters:
    label: PTT
    label0: TX
    label1: RX
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_push_button_CW
  id: variable_qtgui_push_button
  parameters:
    label: cw Key
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_range_0_1
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '144000000'
    step: '1'
    stop: '440000000'
    value: '145500000'
  states: {}
- name: variable_qtgui_range_0_1_0
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '10338000000'
    step: '1'
    stop: '10702000000'
    value: '10352560000'
  states: {}
- name: variable_qtgui_range_Audio_in
  id: variable_qtgui_range
  parameters:
    label: Audio Input Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '0.1'
  states: {}
- name: variable_qtgui_range_Cut_off_freq
  id: variable_qtgui_range
  parameters:
    label: Cut off Freq
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50000'
    value: '16000'
  states: {}
- name: variable_qtgui_range_RF_out_gain
  id: variable_qtgui_range
  parameters:
    label: RF Out Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '15000'
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: variable_qtgui_range_Cut_off_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_Baseband
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_Baseband
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_Baseband_Hackrf
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 19e3
    low_cutoff_freq: 16.3e3
    samp_rate: samp_rate_Baseband
    type: fir_filter_ccf
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_Audio_in
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_RF_out_gain
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_PTT
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_push_button_CW
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_Audio
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anton/gnuradio-grc-examples/test_audio.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: '20'
    freq0: 'variable_qtgui_range_0_1 '
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate_Baseband_Hackrf
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_Baseband
    fc: '0'
    fftsize: '1024'
    name: FFT of Modelation
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_Baseband
    fc: '0'
    fftsize: '1024'
    name: RF Out
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_Baseband
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '25'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '11'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_0_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_2, '0', blocks_selector_0_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_selector_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_selector_0, '0', osmosdr_sink_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_throttle_0, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_1, '0', blocks_selector_0_0, '0']

metadata:
  file_format: 1
