options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_8psk_tx_var_v1
    output_language: python
    realtime_scheduling: '1'
    title: DVB-S2 B200 Transmitter
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0, 1,5
    label: TX Frequency
    label0: 50 MHz
    label1: 437 MHz
    label2: 1'280 MHz
    label3: 10'400 MHz
    num_opts: '4'
    option1: 437e6
    option2: 1280e6
    option3: 10400e6
    orient: Qt.QHBoxLayout
    type: real
    value: 1280e6
    widget: radio_buttons
  states: {}
- name: fec_display
  id: variable_qtgui_label
  parameters:
    formatter: '""'
    gui_hint: 1,3,1,2
    label: 'FEC '
    type: string
    value: '"7/8"'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: symbol_rate_display
  id: variable_qtgui_label
  parameters:
    formatter: '"{0:,}".format'
    gui_hint: 1,1,1,1
    label: '              Symbol Rate [ks/s] '
    type: real
    value: symbol_rate/1000
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,5
    label: Tx Gain [dB]
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '65'
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 10,0,1,5
    label: TRANSMIT
    pressed: '0'
    released: '1'
    type: int
    value: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/hb9dug/Videos/adv16apsk910.ts
    repeat: 'True'
    type: byte
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    rolloff: RO_0_35
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_modulator_bc_0_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C9_10
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,6,5
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
  states: {}
- name: uhd_usrp_sink_0_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0_0, '0']
- [dtv_dvbs2_modulator_bc_0_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fft_filter_xxx_0_0, '0', uhd_usrp_sink_0_0_0, '0']

metadata:
  file_format: 1
