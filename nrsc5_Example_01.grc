options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    qt_qss_theme: /home/user/Documents/dark.qss
  states: {}

blocks:
- name: baseband
  id: variable
  parameters:
    value: 102e6
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    min_len: '40'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: debug
  id: variable
  parameters:
    value: len(taps)
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq01
  id: variable
  parameters:
    value: 101.9e6
  states: {state: disabled}
- name: freq01
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    orient: Qt.Horizontal
    start: 95e6
    step: .1e6
    stop: 105e6
    value: 100e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    min_len: '40'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(200.0, samp_rate,200e3,1000000)
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '127.5'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/user/Documents/sink
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq01-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: bb_gain
    dc_offset_mode0: '1'
    freq0: baseband
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: '1488375'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: '1488375'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '98'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '256'
    interp: '243'
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_float_to_uchar_0, '0', blocks_file_sink_1, '0']
- [blocks_interleave_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_interleave_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
