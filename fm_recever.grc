options:
  parameters:
    author: anton
    generate_options: qt_gui
    id: FM_Recever
    output_language: python
    title: This is an Fm Recever
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Freq (MHz)
    min_len: '10'
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '2000'
    value: '144.7'
    widget: counter
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: int(samp_rate/decimation)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '72'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,7,1,1
    label: Mode
    label0: FM
    label1: AM
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Squelch
    min_len: '10'
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-55'
    widget: counter
  states: {}
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Tune Freq (kHz)
    min_len: '10'
    orient: Qt.Horizontal
    rangeType: int
    start: '-600'
    step: '5'
    stop: '600'
    value: '390'
    widget: counter
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: Volume
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
    widget: counter
  states: {}
- name: xlate_lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: channel_width/2
    gain: '1.0'
    samp_rate: samp_rate
    width: channel_width/10
    win: firdes.WIN_HAMMING
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '3000'
    audio_stop: '4000'
    chan_rate: channel_width
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: channel_width
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/50.0
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq * 1e3
    decim: decimation
    samp_rate: samp_rate
    taps: xlate_lpf_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,2,8
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-90'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: channel_width
    fc: (center_freq *1e6) + (tune_freq *1e3)
    fftsize: '1024'
    gui_hint: 4,0,5,4
    name: '"Channel Spectrum"'
    plotconst: 'False'
    plottime: 'False'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: center_freq * 1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
