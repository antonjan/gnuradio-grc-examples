options:
  parameters:
    author: Anton Janovsky
    category: Custom
    description: 10Ghz_ssb_transmitter_puto
    generate_options: qt_gui
    id: ssb_10Ghz_transmitter_puto
    output_language: python
    title: ssb_10Ghz_transmitter_puto
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Audio input level
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '0.5'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: Side band oselator level
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: RF output Level
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    label: low cut of frequency
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '200'
    value: '50'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: variable_qtgui_range_0_0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '192000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '50'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: variable_qtgui_range_1
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '8'
    gain: '1'
    high_cutoff_freq: '1200'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0_0_0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 48e3
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anton/gnuradio-grc-examples/test_audio.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '100'
    minoutbuf: '10'
    num_taps: '256'
    win: firdes.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    comment: fre:5176280000
    cyclic: 'False'
    frequency: '435000000'
    samplerate: '4000000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '4000000'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [band_pass_filter_1, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
