options:
  parameters:
    author: anton
    generate_options: qt_gui
    id: sampeling_rate
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '23'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: dc block
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '100'
    value: '23'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '-15000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-15000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '6000000'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: variable_qtgui_range_0_0_0
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '25'
    gain: variable_qtgui_range_0_0
    samp_rate: '6000000'
    type: fir_filter_ccf
    width: '20000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=hackrf,soapy=0
    bb_gain0: '40'
    freq0: 435.1e6
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '40'
    sample_rate: '6000000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '960000'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '0']
- [dc_blocker_xx_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
