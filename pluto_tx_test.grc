options:
  parameters:
    author: Anton Janovsky
    generate_options: qt_gui
    id: plut_tx_test
    output_language: python
    title: plut_tx_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: '435000000'
    step: '1'
    stop: '435800000'
    value: '435200000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: variable_qtgui_range_0
    samplerate: '2084000'
  states: {}

connections:
- [blocks_null_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
