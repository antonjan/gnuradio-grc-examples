options:
  parameters:
    author: anton
    description: Geos-13
    generate_options: qt_gui
    id: Goes13
    output_language: python
    title: Geos-13
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1600000000'
    step: '1'
    stop: '1700000000'
    value: '1650000000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=miri
    bb_gain0: '50'
    freq0: variable_qtgui_range_0
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '50'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
