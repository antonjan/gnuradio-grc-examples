options:
  parameters:
    author: Anton Janovsky (ZR6AIC)
    category: Custom
    description: This is a working QO-100 Transmitter
    generate_options: qt_gui
    id: QO_100_Raspberry_Pi_TX
    output_language: python
    title: QO-100-Raspberry-Pi
  states: {}

blocks:
- name: Audio_freq
  id: variable_qtgui_range
  parameters:
    label: Audio Oselator Freq
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '5000'
    value: '1000'
  states: {}
- name: Audio_sel_1
  id: variable_qtgui_chooser
  parameters:
    label: Audio input
    label0: Echolink
    label1: 1Khz
    label2: Play Audio File
    num_opts: '3'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: Tx_freq_0
  id: variable
  parameters:
    value: variable_slider_0
  states: {}
- name: base_freq
  id: variable
  parameters:
    value: 739.200e6
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: bb Gain Hackrf
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '59'
    value: '59'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if Gain hackrf
    orient: Qt.Horizontal
    start: '1'
    step: '0.1'
    stop: '100'
    value: '100'
  states: {}
- name: mixer_level
  id: variable_qtgui_range
  parameters:
    label: Cosinde Mixer Level
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: modelation_amp
  id: variable_qtgui_range
  parameters:
    label: RF output to hackrf
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '.1'
    stop: '100'
    value: '100'
  states: {}
- name: rx_tx_sel
  id: variable_qtgui_chooser
  parameters:
    label: PTT
    label0: TX
    label1: RX
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_qtgui_push_button_0
  id: variable_qtgui_push_button
  parameters:
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: variable_slider_0
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    orient: Qt.Horizontal
    start: 2.4e9
    step: '100'
    stop: 2.40060e9
    value: 2.40029e9
  states: {}
- name: variable_slider_Audio_level
  id: variable_qtgui_range
  parameters:
    label: 1Khz Audio Level
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: variable_slider_Audio_level_0
  id: variable_qtgui_range
  parameters:
    label: Modelation audio input
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.6'
  states: {}
- name: Mic_1khz_selector_0
  id: blks2_selector
  parameters:
    input_index: Audio_sel_1
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: mixer_level
    freq: 50e3
    offset: '0'
    phase: '0'
    samp_rate: 192e3
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: variable_slider_Audio_level
    freq: Audio_freq
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,1
    samp_rate: '48000'
  states: {state: disabled}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: rx_tx_sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blks2_selector_1
  id: blks2_selector
  parameters:
    input_index: rx_tx_sel[0]
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_slider_Audio_level_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_slider_Audio_level_0
    type: complex
    vlen: modelation_amp
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 48e3
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2.4e6
    type: complex
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pi/gnuradio-grc-examples/test_audio.wav
    repeat: 'True'
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '128'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4500'
    decim: '1'
    gain: '1'
    samp_rate: '192000'
    type: fir_filter_ccf
    width: '1004'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf
    bb_gain0: '40'
    comment: |-
      At TX
      RF gain may be 0 or 14dB
      IF gain may be from 0 to 47 dB in 1dB steps
      There is no BB amplifier
      You cant transmit without a correctly adapted antenna (for instance
      without antenna) because impedance disadaptation  may produce reflection
      (without antenna 100% reflection) wich will create an overshoot and can
      destroy the RF amplifier.
      Max TX power depends on TX frequency
      10 MHz to 2150 MHz: 5 dBm to 15 dBm, generally increasing as frequency
      decreases
      2150 MHz to 2750 MHz: 13 dBm to 15 dBm
      2750 MHz to 4000 MHz: 0 dBm to 5 dBm, increasing as frequency decreases
      4000 MHz to 6000 MHz: -10 dBm to 0 dBm, generally increasing as
      frequency decrease
    freq0: 435.1e6
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: '1000000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '1000000'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl
    bb_gain0: '20'
    freq0: 739.2e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: wxgui_scopesink2_0
  id: wxgui_scopesink2
  parameters:
    ac_couple: 'False'
    num_inputs: '1'
    samp_rate: '48000'
    t_scale: '0'
    title: Scope Plot
    trig_mode: wxgui.TRIG_MODE_AUTO
    type: float
    v_offset: '0'
    v_scale: '0'
    xy_mode: 'False'
    y_axis_label: Counts
  states: {state: disabled}
- name: wxgui_waterfallsink2_0
  id: wxgui_waterfallsink2
  parameters:
    average: 'False'
    avg_alpha: '0'
    baseband_freq: 739.2e6
    dynamic_range: '100'
    fft_rate: '4'
    fft_size: '512'
    freqvar: None
    ref_level: '0'
    ref_scale: '2.0'
    samp_rate: 2.4e6
    title: Waterfall Plot
    type: complex
    win: None
  states: {state: disabled}

connections:
- [Mic_1khz_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', Mic_1khz_selector_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', Mic_1khz_selector_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blks2_selector_0, '0', low_pass_filter_0, '0']
- [blks2_selector_1, '0', blocks_null_sink_0, '0']
- [blks2_selector_1, '0', wxgui_waterfallsink2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_null_source_0, '0', blocks_throttle_0_0, '0']
- [blocks_null_source_1, '0', blks2_selector_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', wxgui_scopesink2_0, '0']
- [blocks_throttle_0_0, '0', blks2_selector_1, '0']
- [blocks_wavfile_source_0, '0', Mic_1khz_selector_0, '2']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [hilbert_fc_0, '0', blks2_selector_0, '1']
- [hilbert_fc_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0_0, '1']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [rtlsdr_source_0, '0', blks2_selector_1, '1']

metadata:
  file_format: 1
