options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    qt_qss_theme: /home/user/Documents/dark.qss
  states: {}

blocks:
- name: baseband
  id: variable
  parameters:
    value: 930e6
  states: {}
- name: debug
  id: variable
  parameters:
    value: len(taps)
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq01
  id: variable
  parameters:
    value: 929.6125e6
  states: {}
- name: freq02
  id: variable
  parameters:
    value: 929.6625e6
  states: {}
- name: freq03
  id: variable
  parameters:
    value: 929.9375e6
  states: {}
- name: freq04
  id: variable
  parameters:
    value: 931.0625e6
  states: {}
- name: freq05
  id: variable
  parameters:
    value: 929.0375e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate,200e3,1000000)
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22050'
    max_dev: 15e3
    quad_rate: '22050'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22050'
    max_dev: 15e3
    quad_rate: '22050'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_1
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22050'
    max_dev: 15e3
    quad_rate: '22050'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_2
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22050'
    max_dev: 15e3
    quad_rate: '22050'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_3
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22050'
    max_dev: 15e3
    quad_rate: '22050'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {state: disabled}
- name: audio_sink_0_2
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {state: disabled}
- name: audio_sink_0_3
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_1
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_2
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_0_3
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2001'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2002'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2003'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_2
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2004'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: blocks_udp_sink_0_3
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '2005'
    psize: '1472'
    type: short
    vlen: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq01-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq02-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq03-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq04-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq05-baseband
    decim: decimate
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    affinity: '1'
    cutoff_freq: 10e3
    decim: decimate
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    affinity: '1'
    cutoff_freq: 10e3
    decim: decimate
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_1
  id: low_pass_filter
  parameters:
    affinity: '1'
    cutoff_freq: 10e3
    decim: decimate
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_2
  id: low_pass_filter
  parameters:
    affinity: '1'
    cutoff_freq: 10e3
    decim: decimate
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_3
  id: low_pass_filter
  parameters:
    affinity: '1'
    cutoff_freq: 10e3
    decim: decimate
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '35'
    dc_offset_mode0: '1'
    freq0: baseband
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '35'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: '0'
    fftsize: '512'
    name: freq_01
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: '0'
    fftsize: '512'
    name: freq_01
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: '0'
    fftsize: '512'
    name: freq_01
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: '0'
    fftsize: '512'
    name: freq_01
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_3
  id: qtgui_sink_x
  parameters:
    bw: 20e3
    fc: '0'
    fftsize: '512'
    name: freq_01
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '30'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '441'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '441'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '441'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '441'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_3
  id: rational_resampler_xxx
  parameters:
    decim: '800'
    interp: '441'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', blocks_float_to_short_0, '0']
- [analog_nbfm_rx_0_0, '0', audio_sink_0_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_float_to_short_0_0, '0']
- [analog_nbfm_rx_0_1, '0', audio_sink_0_1, '0']
- [analog_nbfm_rx_0_1, '0', blocks_float_to_short_0_1, '0']
- [analog_nbfm_rx_0_2, '0', audio_sink_0_2, '0']
- [analog_nbfm_rx_0_2, '0', blocks_float_to_short_0_2, '0']
- [analog_nbfm_rx_0_3, '0', audio_sink_0_3, '0']
- [analog_nbfm_rx_0_3, '0', blocks_float_to_short_0_3, '0']
- [blocks_float_to_short_0, '0', blocks_udp_sink_0, '0']
- [blocks_float_to_short_0_0, '0', blocks_udp_sink_0_0, '0']
- [blocks_float_to_short_0_1, '0', blocks_udp_sink_0_1, '0']
- [blocks_float_to_short_0_2, '0', blocks_udp_sink_0_2, '0']
- [blocks_float_to_short_0_3, '0', blocks_udp_sink_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', low_pass_filter_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', low_pass_filter_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', low_pass_filter_1_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_2, '0', low_pass_filter_1_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_3, '0', low_pass_filter_1_3, '0']
- [low_pass_filter_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_1_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_1_1, '0', qtgui_sink_x_0_1, '0']
- [low_pass_filter_1_1, '0', rational_resampler_xxx_0_1, '0']
- [low_pass_filter_1_2, '0', qtgui_sink_x_0_2, '0']
- [low_pass_filter_1_2, '0', rational_resampler_xxx_0_2, '0']
- [low_pass_filter_1_3, '0', qtgui_sink_x_0_3, '0']
- [low_pass_filter_1_3, '0', rational_resampler_xxx_0_3, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_2, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_3, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_nbfm_rx_0_0, '0']
- [rational_resampler_xxx_0_1, '0', analog_nbfm_rx_0_1, '0']
- [rational_resampler_xxx_0_2, '0', analog_nbfm_rx_0_2, '0']
- [rational_resampler_xxx_0_3, '0', analog_nbfm_rx_0_3, '0']

metadata:
  file_format: 1
