options:
  parameters:
    author: Anton Janovsky
    description: AFSK demodulator
    generate_options: qt_gui
    id: AFSKDemo
    output_language: python
    title: AFSK Demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '8000'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '60'
    corr0: '50'
    dc_offset_mode0: '2'
    freq0: '144700000'
    gain0: '60'
    gain_mode0: 'True'
    if_gain0: '60'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '144700000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-10'
    ymin: '-90'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '6000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '6000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '144700000'
    fftsize: '1024'
    grid: 'True'
    int_max: '-10'
    int_min: '-90'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '1700'
    baudrate: '1200'
    deviation: '500'
    iq: 'True'
    samp_rate: samp_rate
  states: {}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_ax25_deframer_0_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_check_address_0
  id: satellites_check_address
  parameters:
    direction: '"from"'
  states: {}
- name: satellites_check_address_0_0
  id: satellites_check_address
  parameters:
    direction: '"from"'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '1200'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_image_receiver_0
  id: satellites_image_receiver
  parameters:
    fullscreen: 'True'
  states: {state: disabled}
- name: satellites_kiss_server_sink_0
  id: satellites_kiss_server_sink
  parameters:
    address: localhost
    port: '8100'
  states: {state: disabled}
- name: satellites_telemetry_parser_0
  id: satellites_telemetry_parser
  parameters:
    definition: tmp
    output: stdout
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [osmosdr_source_0, '0', analog_nbfm_rx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', satellites_afsk_demodulator_0, '0']
- [satellites_afsk_demodulator_0, '0', blocks_head_0, '0']
- [satellites_afsk_demodulator_0, '0', qtgui_time_sink_x_0, '0']
- [satellites_afsk_demodulator_0, '0', qtgui_time_sink_x_1_0, '0']
- [satellites_afsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']
- [satellites_afsk_demodulator_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_ax25_deframer_0, out, satellites_check_address_0, in]
- [satellites_ax25_deframer_0, out, satellites_hexdump_sink_0, in]
- [satellites_ax25_deframer_0, out, satellites_image_receiver_0, in]
- [satellites_ax25_deframer_0, out, satellites_kiss_server_sink_0, in]
- [satellites_ax25_deframer_0, out, satellites_telemetry_parser_0, in]
- [satellites_ax25_deframer_0_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_ax25_deframer_0_0, out, satellites_check_address_0_0, in]
- [satellites_ax25_deframer_0_0, out, satellites_hexdump_sink_0_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0_0, '0']

metadata:
  file_format: 1
