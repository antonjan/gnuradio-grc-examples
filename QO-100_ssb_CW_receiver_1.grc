options:
  parameters:
    author: Anton Janovsky ZR6AIC
    description: QO-100 SSB and CW recever
    generate_options: qt_gui
    id: qo_100_ssb_cw_rx
    output_language: python
    title: QO-100 ssb and CW resever
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: variable_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: Filter - CW
    label0: '900'
    label1: '500'
    label2: '200'
    label3: SSB (2.7khz)
    num_opts: '4'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: variable_slider_0
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '-24e3'
    step: '1'
    stop: 24e3
    value: 11.5e3
  states: {}
- name: variable_slider_1
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.01'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '700'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '1100'
    low_cutoff_freq: '300'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '950'
    low_cutoff_freq: '450'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '800'
    low_cutoff_freq: '600'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '100'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '50'
    win: firdes.WIN_HAMMING
  states: {}
- name: blks2_selector_0
  id: blks2_selector
  parameters:
    input_index: variable_chooser_0
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
    vlen: '1'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_slider_1
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_chooser_0
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: variable_slider_0
    decim: '25'
    samp_rate: 1.2e6
    taps: firdes.low_pass(1,48000,500,50)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: 145.825e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '1', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', blks2_selector_0, '0']
- [band_pass_filter_0, '0', blocks_selector_0, '0']
- [band_pass_filter_1, '0', blks2_selector_0, '1']
- [band_pass_filter_1, '0', blocks_selector_0, '1']
- [band_pass_filter_2, '0', blks2_selector_0, '2']
- [band_pass_filter_2, '0', blocks_selector_0, '2']
- [band_pass_filter_2_0, '0', blocks_selector_0, '3']
- [blks2_selector_0, '0', analog_agc2_xx_0, '0']
- [blks2_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_1, '0']
- [blocks_add_xx_0, '0', band_pass_filter_2, '0']
- [blocks_add_xx_0, '0', band_pass_filter_2_0, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_1, '1', blocks_multiply_xx_1, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', analog_agc2_xx_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_1, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
