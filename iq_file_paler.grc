options:
  parameters:
    author: Anton
    generate_options: qt_gui
    id: IQ_file_payer
    output_language: python
    title: IQ_file_paler
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/anton/Videos/gqrx_20211030_065912_145932000_1800000_fc.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '145932000'
    fftsize: '1024'
    name: Africube_transponder
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
