options:
  parameters:
    author: Anton Janovsky ZR6AIC
    category: Custom
    generate_options: qt_gui
    id: ssb_tx_pluto
    output_language: python
    title: ssbtx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: Modulator amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: Mixer Aplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: RF Output Level
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: variable_qtgui_range_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '2400000'
    step: '1'
    stop: '2410000'
    value: '2400000'
  states: {}
- name: variable_qtgui_range_0_0_0_1
  id: variable_qtgui_range
  parameters:
    label: RF Output Level
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '4'
    value: '1'
  states: {}
- name: variable_qtgui_range_0_0_0_1_0
  id: variable_qtgui_range
  parameters:
    label: RF Output Level hackrf
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '80'
    value: '60'
  states: {}
- name: variable_qtgui_range_0_0_0_1_0_0
  id: variable_qtgui_range
  parameters:
    label: IF Output Level hackrf
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '80'
    value: '60'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: variable_qtgui_range_0_0
    freq: '1'
    offset: '0'
    phase: '0'
    samp_rate: '192000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '200'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '200'
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '8'
    gain: '1'
    high_cutoff_freq: '1200'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: variable_qtgui_range_0_0_0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '3'
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 48e3
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anton/gnuradio-grc-examples/test_audio.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '256'
    win: firdes.WIN_HAMMING
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '2400000000'
    samplerate: '2084000'
    uri: ip:pluto.local
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '4000000'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_real_0, '0']
- [analog_noise_source_x_0, '0', blocks_selector_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_selector_0, '1']
- [audio_source_0, '0', blocks_selector_0, '2']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [band_pass_filter_1, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_selector_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_selector_0, '3']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
