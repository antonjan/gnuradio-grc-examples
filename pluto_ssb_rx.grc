options:
  parameters:
    author: Anton Janovsky
    description: plutosdr ssb rx
    generate_options: qt_gui
    id: pluto_ssb_rx
    output_language: python
    title: pluto_ssb_rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: |-
      rx_freq 10352560000hz
      tx on 5176280000
    frequency: '940000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
