options:
  parameters:
    author: Anton Janovsky
    generate_options: qt_gui
    id: The_10G_second_harmonic_pluto
    output_language: python
    title: 10Ghz 2de Garmonic with pluto
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '4800000'
  states: {}
- name: variable_qtgui_chooser_PTT_0
  id: variable_qtgui_chooser
  parameters:
    label: PTT
    label0: TX
    label1: RX
    num_opts: '2'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: freq
    type: real
    value: variable_qtgui_range_0_1 / 2
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    label: div
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 12.5e3
    value: 2.5e3
  states: {}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    label: tx_power
    orient: Qt.Horizontal
    start: '10'
    step: '1'
    stop: '65'
    value: '60'
  states: {}
- name: variable_qtgui_range_0_0_0
  id: variable_qtgui_range
  parameters:
    label: if_power
    orient: Qt.Horizontal
    start: '5'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: variable_qtgui_range_0_0_0_0
  id: variable_qtgui_range
  parameters:
    label: bb_power
    orient: Qt.Horizontal
    start: '5'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: variable_qtgui_range_0_1
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '435000000'
    step: '1'
    stop: '435200000'
    value: '435105000'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: variable_qtgui_range_0
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_PTT_0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anton/gnuradio-grc-examples/test_audio.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: '435105000'
    samplerate: samp_rate
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: variable_qtgui_range_0_0_0_0
    freq0: variable_qtgui_range_0_1 / 2
    gain0: variable_qtgui_range_0_0
    if_gain0: variable_qtgui_range_0_0_0
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_selector_0, '1']
- [analog_nbfm_tx_0_0, '0', blocks_selector_0, '0']
- [analog_wfm_tx_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_throttle_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
