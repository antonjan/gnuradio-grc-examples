<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs_tx_var_v4</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>DVB-S B200 Transmitter</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1280e6</value></param>
<param><key>gui_hint</key><value>0,0, 1,5</value></param>
<param><key>label0</key><value>50 MHz</value></param>
<param><key>label1</key><value>437 MHz</value></param>
<param><key>label2</key><value>1'280 MHz</value></param>
<param><key>label3</key><value>10'400 MHz</value></param>
<param><key>label</key><value>TX Frequency</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>50e6</value></param>
<param><key>option1</key><value>437e6</value></param>
<param><key>option2</key><value>1280e6</value></param>
<param><key>option3</key><value>10400e6</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>fec_display</value></param>
<param><key>value</key><value>"7/8"</value></param>
<param><key>formatter</key><value>""</value></param>
<param><key>gui_hint</key><value>1,3,1,2</value></param>
<param><key>label</key><value>FEC </value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>symbol_rate_display</value></param>
<param><key>value</key><value>symbol_rate/1000</value></param>
<param><key>formatter</key><value>"{0:,}".format</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>              Symbol Rate [ks/s] </value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>65</value></param>
<param><key>gui_hint</key><value>9,0,1,5</value></param>
<param><key>label</key><value>Tx Gain [dB]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>variable_qtgui_push_button_0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>10,0,1,5</value></param>
<param><key>label</key><value>TRANSMIT</value></param>
<param><key>pressed</key><value>0</value></param>
<param><key>released</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/hb9dug/grc-files/prototypes/test1.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbs2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbs2_modulator_bc_0</value></param>
<param><key>interpolation</key><value>INTERPOLATION_ON</value></param>
<param><key>rate1</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_QPSK</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt_convolutional_interleaver</key>
<param><key>id</key><value>dtv_dvbt_convolutional_interleaver_0</value></param>
<param><key>blocks</key><value>136</value></param>
<param><key>M</key><value>17</value></param>
<param><key>I</key><value>12</value></param>
</block>
<block>
<key>dtv_dvbt_energy_dispersal</key>
<param><key>id</key><value>dtv_dvbt_energy_dispersal_0</value></param>
<param><key>nsize</key><value>1</value></param>
</block>
<block>
<key>dtv_dvbt_inner_coder</key>
<param><key>id</key><value>dtv_dvbt_inner_coder_0</value></param>
<param><key>code_rate</key><value>C5_6</value></param>
<param><key>constellation</key><value>qpsk</value></param>
<param><key>hierarchy</key><value>nh</value></param>
<param><key>ninput</key><value>1</value></param>
<param><key>noutput</key><value>1512</value></param>
</block>
<block>
<key>dtv_dvbt_reed_solomon_enc</key>
<param><key>id</key><value>dtv_dvbt_reed_solomon_enc_0</value></param>
<param><key>blocks</key><value>8</value></param>
<param><key>gfpoly</key><value>0x11d</value></param>
<param><key>k</key><value>239</value></param>
<param><key>n</key><value>255</value></param>
<param><key>s</key><value>51</value></param>
<param><key>m</key><value>8</value></param>
<param><key>p</key><value>2</value></param>
<param><key>t</key><value>8</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, 0.35, rrc_taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,6,5</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, ((symbol_rate * 1.35) / 2 ) + 1e5)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=65536,num_send_frames=256,master_clock_rate=" + str(samp_rate*2)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>True</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>dtv_dvbt_energy_dispersal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>dtv_dvbs2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_modulator_bc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_convolutional_interleaver_0</source_block_id><sink_block_id>dtv_dvbt_inner_coder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_energy_dispersal_0</source_block_id><sink_block_id>dtv_dvbt_reed_solomon_enc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_inner_coder_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt_reed_solomon_enc_0</source_block_id><sink_block_id>dtv_dvbt_convolutional_interleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
